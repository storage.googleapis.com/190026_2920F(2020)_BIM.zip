Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-10T06:05:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 10 06:05:52 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{2C91C6D6-2B91-42F5-BEA1-F7731406946D}\ifc * Database version: 5507 * Database creation date: Fri Aug 10 06:05:52 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 10 06:05:52 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 10 06:05:52 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 2920F Kitchen faucet, 2920F:2920F Kitchen faucet:328799
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 16 mm; NominalDepth: 249 mm; NominalHeight: 198.5 mm; NominalWidth: 51 mm; Projection: 210 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 2920F; ConvergoRefNr: 0087-1809-0046-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_20_87_07; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 09/08/2018
Type - Green Building Properties(Type) - EAN Number: 6414150058288; EN Standard: EN 817; VVS Number: 705882104
Type - Identity Data(Type) - Class: Single lever; Group: Kitchen faucets; Manufacturer: Oras; Market: POL;RUS;LTU;LVA;UKR; Model: 2920F Kitchen faucet; Name_en: 2920F Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2920F; Product Datasheet: https://www.oras.com/datasheet/2920F/en; Product Family: Oras Aquita; Product URL: https://www.oras.com/en/products/oras/product/2920F; Type Name: 2920F Kitchen faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G3/8; Flow Rate At 300kPa: 0.00706293 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/109932_PDM_943152_3_(943152-10-16).pdf; Installation Type: Deck mounted; Max. Hot Water Supply: 90 kg/K/s3; Pressure Loss With Flow 02ls: 300000 Pa; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP2920F/; Spout Type: Swivel spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2920F; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2920F; Name: 2920F Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x250x200 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2920F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2920F Kitchen faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.074159 m2; Volume: 0.00253281 m3
Identity Data - Mark: 8
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 2920F: 2920F Kitchen faucet; Family and Type: 2920F: 2920F Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2920F: 2920F Kitchen faucet; Type Id: 2920F: 2920F Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
